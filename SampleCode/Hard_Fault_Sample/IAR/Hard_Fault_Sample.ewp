# IAR project Hard_Fault_Sample.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M030G series Nuvoton M030G series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\Device\Nuvoton\M030G\Include; ..\..\..\Library\StdDriver\Inc; ..\..\..\Library\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Hard_Fault_Sample.bin
  ILINK.IlinkOutputFile: Hard_Fault_Sample.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M030G/Source/IAR/: startup_M030G.s
    ../../../Library/Device/Nuvoton/M030G/Source/: system_M030G.c
  group Libraries
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
