# Keil uVision project SYS_PLLClockOutput.uvproj, settings and files
target SYS_PLLClockOutput (ARM-ADS)
  device: M031GTD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: SYS_PLLClockOutput
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M030G\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_M030G.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M030G/Source/: system_M030G.c
    ../../../../Library/Device/Nuvoton/M030G/Source/ARM/: startup_M030G.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c gpio.c sys.c
  group User
    ../: main.c
