# IAR project I2C_PDMA_TRX.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M030G series Nuvoton M030G series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M030G\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_PDMA_TRX.bin
  ILINK.IlinkOutputFile: I2C_PDMA_TRX.out
  ILINK.IlinkIcfFile: I2C_PDMA_TRX.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/M030G/Source/IAR/: startup_M030G.s
    ../../../../Library/Device/Nuvoton/M030G/Source/: system_M030G.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c i2c.c pdma.c retarget.c uart.c
  group Source Files
    ../: main.c
