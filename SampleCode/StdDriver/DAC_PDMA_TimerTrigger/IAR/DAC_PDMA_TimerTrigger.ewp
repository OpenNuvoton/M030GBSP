# IAR project DAC_PDMA_TimerTrigger.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M030G series Nuvoton M030G series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M030G\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DAC_PDMA_TimerTrigger.bin
  ILINK.IlinkOutputFile: DAC_PDMA_TimerTrigger.out
  ILINK.IlinkIcfFile: DAC_PDMA_TimerTrigger.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M030G/Source/IAR/: startup_M030G.s
    ../../../../Library/Device/Nuvoton/M030G/Source/: system_M030G.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c dac.c pdma.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
