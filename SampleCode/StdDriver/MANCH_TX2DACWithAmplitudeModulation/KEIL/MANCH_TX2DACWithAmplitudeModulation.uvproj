# Keil uVision project MANCH_TX2DACWithAmplitudeModulation.uvproj, settings and files
target MANCH_TX2DACWithAmplitudeModulation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M030GGD1AE Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: MANCH_TX2DACWithAmplitudeModulation
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M030G\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M030G.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M030G/Source/: system_M030G.c
    ../../../../Library/Device/Nuvoton/M030G/Source/ARM/: startup_M030G.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c manch.c pdma.c dac.c timer.c
