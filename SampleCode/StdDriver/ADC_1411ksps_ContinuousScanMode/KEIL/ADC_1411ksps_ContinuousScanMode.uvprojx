# Keil uVision project ADC_1411ksps_ContinuousScanMode.uvprojx, settings and files
target ADC_1411ksps_ContinuousScanMode (ARM-ADS)
  device: M030GTD1AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.24
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: ADC_1411kSPS_ContinuousScanMode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M030G\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M030G.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M030G/Source/: system_M030G.c
    ../../../../Library/Device/Nuvoton/M030G/Source/ARM/: startup_M030G.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c adc.c sys.c gpio.c
  group User
    ../: main.c
