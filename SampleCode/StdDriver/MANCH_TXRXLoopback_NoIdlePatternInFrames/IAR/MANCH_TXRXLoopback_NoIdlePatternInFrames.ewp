# IAR project MANCH_TXRXLoopback_NoIdlePatternInFrames.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M030G series Nuvoton M030G series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M030G\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MANCH_TXRXLoopback_NoIdlePatternInFrames.bin
  ILINK.IlinkOutputFile: MANCH_TXRXLoopback_NoIdlePatternInFrames.out
  ILINK.IlinkIcfFile: MANCH_TXRXLoopback_NoIdlePatternInFrames.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M030G/Source/IAR/: startup_M030G.s
    ../../../../Library/Device/Nuvoton/M030G/Source/: system_M030G.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c crc.c dac.c gpio.c manch.c pdma.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c manchester_decode.c manchester_encode.c
