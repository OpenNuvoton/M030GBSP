# Keil uVision project MANCH_TXRXLoopback_NoIdlePatternInFrames.uvproj, settings and files
target MANCH_TXRXLoopback_NoIdlePatternInFrames (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M031GTD2AE Nuvoton
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0-0xFFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: MANCH_TXRXLoopback_NoIdlePatternInFrames
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M030G\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_M030G.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M030G/Source/: system_M030G.c
    ../../../../Library/Device/Nuvoton/M030G/Source/ARM/: startup_M030G.s
  group User
    ../: main.c manchester_encode.c manchester_decode.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c manch.c pdma.c gpio.c timer.c dac.c crc.c
