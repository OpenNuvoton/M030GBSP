# IAR project CRC_POLYNOMIAL.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M030G series Nuvoton M030G series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M030G\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CRC_POLYNOMIAL.bin
  ILINK.IlinkOutputFile: CRC_POLYNOMIAL.out
  ILINK.IlinkIcfFile: CRC_POLYNOMIAL.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M030G/Source/IAR/: startup_M030G.s
    ../../../../Library/Device/Nuvoton/M030G/Source/: system_M030G.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c crc.c retarget.c sys.c uart.c
  group User
    ../: main.c sw_crc.c
